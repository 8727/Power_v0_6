# Keil uVision project Power_v0_6.uvprojx, settings and files
target Power_v0_6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power_v0_6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Power_v0_6;.\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_cl.s
  group Source
    ../SOURCE/src/: main.c setting.c start_timer.c Ee24cxx.c rtc.c w25qxx.c s6d0129.c gui.c en485.c ds18b20.c dht22.c can.c rs485.c nrf24.c beep.c
